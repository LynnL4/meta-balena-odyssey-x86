IMAGE_INSTALL_append_odyssey-x86 =" \
    linux-firmware                        \
"

IMAGE_ROOTFS_SIZE_odyssey-x86 = "1024000"
