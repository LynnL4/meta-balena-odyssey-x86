PACKAGE_INSTALL_append_odyssey-x86 = " acpi-tables"